options:
  parameters:
    author: xxx
    description: Чтение бинарного IQ файла с заданной частотой дискритезации
    generate_options: qt_gui
    id: read_bin_iq
    output_language: python
    title: Извлечение AIS пакета из IQ сигнала
  states: {}

blocks:
- name: ais_bitrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: ais_fsk_deviation_hz
  id: variable
  parameters:
    value: ais_modulation_index * ais_bitrate / 2
  states: {}
- name: ais_modulation_index
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: bandwidth_ais
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: filter_span
  id: variable
  parameters:
    value: '9'
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: '162000000'
  states: {}
- name: freq_high_ais_0
  id: variable
  parameters:
    value: '162025000'
  states: {}
- name: freq_low_ais
  id: variable
  parameters:
    value: '161975000'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159'
  states: {}
- name: resampling_koeff
  id: variable
  parameters:
    value: samp_rate/(4*ais_bitrate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: samp_rate_resample
  id: variable
  parameters:
    value: samp_rate/resampling_koeff
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '10000'
    rate: '1e-3'
    reference: '0.5'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate_resample/(pi*ais_bitrate)
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: ''
    file: /home/xxx/Рабочий стол/AIS/records/ais_records_raw/iq_1765716337.raw
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    log_level: debug
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/32768.0
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/32768.0
    type: float
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"frame_start"'
    name: '"Ais Detector"'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/xxx/Рабочий стол/AIS/records/ais_records_wav/iq_1765716233.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_1_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01010101010101010101010101111110'
    tagname: '"frame_start"'
    threshold: '2'
    type: byte
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    modulus: '0'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '256'
    rolloff: '0.55'
    samps_per_sym: samp_rate_resample / ais_bitrate
    type: cc
    w: '0.01'
  states: {state: disabled}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '26'
    min: '20'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0.5'
    loop_bw: '0.0005'
    max_dev: '1.5'
    osps: '1'
    sps: samp_rate_resample / ais_bitrate
    taps: firdes.gaussian(gain=1.0, spb=samp_rate_resample / ais_bitrate,bt=0.4, ntaps=int(filter_span*samp_rate_resample / ais_bitrate))
    type: fff
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '0.707'
    loop_bw: '0.0005'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_rate_resample / ais_bitrate
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-23600'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bandwidth_ais/2, transition_bw)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '1.0'
    cutoff_freq: 0.6*ais_bitrate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_resample
    type: fir_filter_fff
    width: 0.5*ais_fsk_deviation_hz
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_2_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Demod
    size: '10000'
    srate: samp_rate
    tr_level: '0.025'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: ''
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_center
    fftsize: '8192'
    name: Raw file source
    showports: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_resample
    fc: freq_low_ais
    fftsize: '8192'
    name: FIR
    showports: 'True'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(resampling_koeff)
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_throttle2_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_2_0_1_0, '0']
- [blocks_deinterleave_0, '0', blocks_short_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0, '0', blocks_deinterleave_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_throttle2_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0_0, '1']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_tag_xx_1_1, '0', blocks_tag_debug_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_tag_xx_1_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_hdlc_deframer_bp_0, '0']
- [digital_fll_band_edge_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_1, print]
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_1, '0', digital_fll_band_edge_cc_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
