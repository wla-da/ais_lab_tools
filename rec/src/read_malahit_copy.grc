options:
  parameters:
    author: wla-da
    generate_options: qt_gui
    id: read_malahit
    output_language: python
    title: Приемник Малахит DSP3
  states: {}

blocks:
- name: freq_center
  id: variable
  parameters:
    value: '162000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:CARD=reciever,DEV=1
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Malahit source
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Malahit source
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_center
    fftsize: '4096'
    name: Malahit source
    showports: 'True'
    type: complex
    update_time: '0.02'
  states: {}

connections:
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [audio_source_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
